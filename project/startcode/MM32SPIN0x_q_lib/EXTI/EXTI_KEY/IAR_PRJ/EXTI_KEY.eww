<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EXTI_KEY.ewp</path>
  </project>
  <batchBuild/>
</workspace>


