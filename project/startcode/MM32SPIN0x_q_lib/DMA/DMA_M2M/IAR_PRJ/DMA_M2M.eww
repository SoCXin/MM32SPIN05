<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DMA_M2M.ewp</path>
  </project>
  <batchBuild/>
</workspace>


