# Keil uVision project MotorFoc.uvprojx, settings and files
target MM32SP05XX (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32SPIN05PF MindMotion
  pack: MindMotion.MM32SPIN0x_DFP.1.0.6
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MotorFoc +hex
  AfterMake: fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=3 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Device\CMSIS\KEIL_CORE;..\SYSTEM\delay;..\SYSTEM\uart;..\SYSTEM\sys;..\HARDWARE\LED;..\..\Device\MM32F031x4x6_q\HAL_lib\inc;..\..\Device\MM32F031x4x6_q\Include;..\HARDWARE\KEY;..\HARDWARE\ADC;..\HARDWARE\IWDG;..\USER;..\HARDWARE\PWM;..\HARDWARE\PVD;..\..\Device\MM32SPIN0x_q\HAL_lib\inc;..\..\Device\MM32SPIN0x_q\HAL_lib\src;..\..\Device\MM32SPIN0x_q\Include;..\..\..\MM32SPIN05_q_FOC_FOR_T
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group STARTUP
    ../../Device/MM32SPIN0x_q/Source/: system_MM32SPIN0x_q.c
    ../../Device/MM32SPIN0x_q/Source/KEIL_StartAsm/: startup_MM32SPIN0x_q.s
  group HALlib
    ../../Device/MM32SPIN0x_q/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_comp.c HAL_crc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_hdiv.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group USER
    ../USER/: main.c Motor_Function_Initial.c Initial_BEMF_Speed_Detect.c Motor_Speed_Slop_Control.c Sin_Table.c FOC_PMSM.c PI.c CurrentSensing.c SVPWM.c ROTOR_IPD.c GPIO.c MotorFocSH20190828.lib
  group SYSTEM
    ../SYSTEM/UART/: uart.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../USER/: delay2.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/PVD/: pwr_pvd.c
  group README
    ../../: README.TXT
