# IAR project DIV_COMP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32SPIN05PF MindMotion MM32SPIN05PF
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_IAR
  ICCARM.CCIncludePath2: ..\..\..\..\..\Device\CMSIS\IAR_CORE; ..\..\..\..\..\Device\MM32SPIN0x_q\Include; ..\..\..\..\..\Device\MM32SPIN0x_q\HAL_lib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IOToggle.srec
  ILINK.IlinkOutputFile: MM32.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group HALlib
    ../../../../../Device/MM32SPIN0x_q/HAL_lib/src/: HAL_adc.c HAL_comp.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group README
    ../: README.TXT
  group STARTUP
    ../../../../../Device/MM32SPIN0x_q/Source/IAR_StartAsm/: startup_MM32SPIN0x_q.s
    ../../../../../Device/MM32SPIN0x_q/Source/: system_MM32SPIN0x_q.c
  group USER
    ../USER/: main.c
